Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: \\ur38nt01\Public\Модели\Облегченные_модели\РГ-Т + корректор\C1 PN16\Модели ifc\РГ-Т G1600-G4000-DN300-PN16-C1_с масл.насосом+EK270.ifc
Time: 2026-06-24T09:40:58
Written by: IFCConverter v1.0
Made in: KOMPAS-3D 21.0.1463

# IfcProject, Default project
Phase: MODIFIED

# IfcBuildingElementProxy, РГ-Т G1600-G4000-DN300-PN16-C1_с масл.насосом+EK270
In: Default building
System - Масса: 138.439 kg; Материал: Сталь 10 ГОСТ 1050-2013; Наименование: РГ-Т G1600-G4000-DN300-PN16-C1_с масл.насосом+EK270
IfcPropertySet - __ComponentName: РГ-Т G1600-G4000-DN300-PN16-C1_с масл.насосом+EK270
