Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: \\ur38nt01\Public\Модели\Облегченные_модели\РГ-Т + корректор\T1 PN16\Модели ifc\РГ-Т G1000-G2500-DN250-PN16 -T1+EK270.ifc
Time: 2026-06-17T11:22:18
Written by: IFCConverter v1.0
Made in: KOMPAS-3D 21.0.1463

# IfcProject, Default project
Phase: MODIFIED

# IfcBuildingElementProxy, РГ-Т G1000-G2500-DN250-PN16 -T1+EK270
In: Default building
System - Масса: 105.562 kg; Материал: Сталь 10 ГОСТ 1050-2013; Наименование: РГ-Т G1000-G2500-DN250-PN16 -T1+EK270
IfcPropertySet - __ComponentName: РГ-Т G1000-G2500-DN250-PN16 -T1+EK270
